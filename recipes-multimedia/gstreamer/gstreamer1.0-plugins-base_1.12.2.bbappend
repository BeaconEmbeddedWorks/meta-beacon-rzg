CFLAGS_remove = "-O2"

CFLAGS_append = " -O3 -ftree-loop-vectorize"
