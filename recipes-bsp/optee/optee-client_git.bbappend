COMPATIBLE_MACHINE_append = "|logicpd-rzg2m"
