COMPATIBLE_MACHINE_append = "|beacon-rzg2m|beacon-rzg2n|beacon-rzg2h"

PLATFORM_FLAVOR = "hihope_rzg2m"