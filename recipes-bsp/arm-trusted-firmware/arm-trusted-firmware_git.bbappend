COMPATIBLE_MACHINE_append = "|beacon-rzg2m"
