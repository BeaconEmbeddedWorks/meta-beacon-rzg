FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-Modify-to-support-Beacon-EmbeddedWorks-development-k.patch \
"
