require optee-examples.inc

COMPATIBLE_MACHINE += "|beacon-rzg2m|beacon-rzg2n|beacon-rzg2h"

#TAG: 3.12.0
SRCREV = "9a755dcf4d8ef6117af59dfd1b1a82315cee58ca"
