MMNGR_CFG_logicpd-rzg2m = "MMNGR_SALVATORX"
